# Keil uVision project ModBus_Master.uvprojx, settings and files
target ModBus_Master (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GGX-FWQ-3630-BLE-0911 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\NB_MODEL;..\HARDWARE\Key;..\HARDWARE\Led;..\HARDWARE\usart;..\HARDWARE\adc;..\HARDWARE\GeneralTim;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\height
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/NB_MODEL/: nb_model.c bsp_nb.c
    ../HARDWARE/usart/: bsp_usart5.c
    ../HARDWARE/adc/: bsp_adc.c
    ../HARDWARE/GeneralTim/: bsp_GeneralTim.c
    ../HARDWARE/height/: height.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/Key/: bsp_key.c
    ../HARDWARE/Led/: bsp_led.c
    ../SYSTEM/usart/: usart.c
    ./: rl_control.c iwdg.c flash.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_sdio.c
